<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>python_txrx</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>rx_server_address</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>rx_server_port</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_CLIENT"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_1</value></param>
<param><key>host</key><value>tx_server_address</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>tx_server_port</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>blocks_tuntap_pdu</key>
<param><key>id</key><value>blocks_tuntap_pdu_0</value></param>
<param><key>istunflag</key><value>True</value></param>
<param><key>ifn</key><value>interface_name</value></param>
<param><key>mtu</key><value>10000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>interface_name</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>tunCRTS</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_server_address</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>192.168.1.56</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_server_port</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>52002</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_server_address</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>192.168.1.55</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_server_port</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>52001</value></param>
</block>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdus</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>blocks_tuntap_pdu_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_tuntap_pdu_0</source_block_id><sink_block_id>blocks_socket_pdu_1</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>
